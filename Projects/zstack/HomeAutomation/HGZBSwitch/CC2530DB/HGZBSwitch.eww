<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\HGZBSwitch.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>HGZBSwitch</project>
        <configuration>RouterEB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
